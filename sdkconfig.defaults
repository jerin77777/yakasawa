## sdkconfig.defaults
```kconfig
# ESP32-S3 Yaskawa GA700 RS485 Configuration
CONFIG_IDF_TARGET="esp32s3"
CONFIG_ESP_MAIN_TASK_STACK_SIZE=4096
CONFIG_FREERTOS_HZ=1000
```
